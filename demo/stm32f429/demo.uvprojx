# Keil uVision project demo.uvprojx, settings and files
target stm32f429 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\driver;.\Sources\kernel;..\..\sources\kernel;.\Sources\cpu\cmsis;.\Sources\cpu\lib;..\..\sources\misc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./Sources/main/: main.c log.c
  group driver
    ./Sources/driver/: gpio.c nvic.c uart.c
  group misc
    ../../sources/misc/: fifo.c mbox.c mpool.c timer.c
  group kernel
    ../../sources/kernel/: event.c heap.c kernel.c mutex.c tasklet.c thread.c scheduler.c semaphore.c
  group cpu
    ./Sources/cpu/: startup_stm32f429_439xx.s system_stm32f4xx.c
    ./Sources/cpu/lib/: STM32F429.lib
  group port
    ./Sources/kernel/: port.c
    ../../sources/kernel/port/cortex-m4/: cpu.c cpu_asm_keil.s
