# Keil uVision project build.uvprojx, settings and files
target cortex-m3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kernel-cm3 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\driver;.\Sources\kernel
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group kernel
    ./Sources/: kernel.c cpu_init.c cpu_core_cm4.c cpu_core_cm3.c
target cortex-m4 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401CBUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kernel-cm4 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\driver;.\Sources\kernel
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
